# Keil uVision project bnglore.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: bnglore +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: roll.c
